# Keil uVision project stm32f100RB_demo.uvprojx, settings and files
target STM32F100RB-Discovery (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f100RB_demo
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\Header Files
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Files
    ./Source Files/: main.c
  group Library Files
    ./Library Files/: IRQ_SysTick.c Delay.c
  group Header Files
    ./Header Files/: User.h Delay.h
software components: CMSIS:CORE 4.1.0, Device:GPIO 1.01.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
